# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AVR +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\User;..\Hardware\Inc;..\Firmware\PY32F0xx_HAL_Driver\Inc;..\Firmware\CMSIS\Include;..\EWARM;..\Firmware\CMSIS\Device\PY32F0xx\Include;..\MDK-ARM;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group User
    ../User/: main.c py32f0xx_hal_msp.c py32f002xx_Start_Kit.c py32f0xx_it.c system_py32f0xx.c
  group Hardware
    ../Hardware/Src/: adc.c relay.c aip1820.c
  group CMSIS
    ./: startup_py32f002xx.s
  group App
    ../App/: app.c
  group Doc
    ../: readme.txt
  group Firmware
    ../Firmware/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_rcc.c py32f0xx_hal_cortex.c py32f0xx_hal_pwr.c
software components: CMSIS:CORE 5.2.0
